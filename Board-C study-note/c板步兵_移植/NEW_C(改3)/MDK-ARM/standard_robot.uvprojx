# Keil uVision project standard_robot.uvprojx, settings and files
target standard_robot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: standard_robot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Muc_robolab\Inc;..\Hardware\Inc;..\IMU;..\IMU\algorithm;..\IMU\BMI088;..\IMU\IST8310
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c crc.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Muc_Hardware
    ../Hardware/Src/: muc_hardware_beep.c muc_hardware_can.c muc_hardware_key.c muc_hardware_spi.c muc_hardware_stmflash.c muc_hardware_super_capacity.c muc_hardware_uart.c
  group Muc_robolab
    ../Muc_robolab/Src/: muc_auto_shoot.c muc_chassis.c muc_gimbal.c muc_gimbal_chassis.c muc_imu.c muc_Kalman.c muc_led.c muc_main_task.c muc_pid.c muc_referee_system.c muc_remote.c muc_Shoot_Judge_Control.c muc_shoot_mode.c muc_shoot_wheel.c muc_stir_wheel.c muc_stmflash.c muc_super_capacity.c muc_test.c muc_timer.c protocol.c remote_control.c
  group IMU
    ../IMU/IST8310/: ist8310driver.c ist8310driver_middleware.c
    ../IMU/BMI088/: BMI088driver.c BMI088Middleware.c
  group algorithm
    ../IMU/algorithm/: MahonyAHRS.c pid.c user_lib.c
  group Application/MKD-ARM
    ./: startup_stm32f407xx.s
software components: CMSIS:CORE 4.3.0
