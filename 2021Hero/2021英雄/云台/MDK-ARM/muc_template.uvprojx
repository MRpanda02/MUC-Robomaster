# Keil uVision project muc_template.uvprojx, settings and files
target muc_template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: muc_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Muc_robolab\Inc; ..\Muc_robolab\Hardware; ..\Muc_robolab\Mpu6050; .\muc_template
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c spi.c tim.c can.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Muc_Hardware
    ../Muc_robolab/Hardware/: muc_hardware_can.c muc_hardware_uart.c muc_hardware_stmflash.c muc_hardware_key.c muc_hardware_beep.c muc_hardware_super_capacity.c
  group Muc_Robolab
    ../Muc_robolab/Src/: muc_led.c muc_pid.c muc_remote.c muc_test.c muc_timer.c muc_main_task.c muc_gimbal.c muc_imu.c muc_stmflash.c muc_chassis.c muc_shoot_wheel.c muc_referee_system.c muc_stir_wheel.c muc_gimbal_chassis.c protocol.c muc_auto_pid.c muc_visual_tasks.c
    ./muc_template/: muc_shoot_mode.c muc_Shoot_Judge_Control.c muc_Kalman.c
  group Mpu6050
    ../Muc_robolab/Mpu6050/: mpu6500.c
  group Readme
    ../: readme.md
software components: CMSIS:CORE 5.1.1
